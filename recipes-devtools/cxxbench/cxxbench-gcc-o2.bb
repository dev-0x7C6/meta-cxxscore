LICENSE = "CLOSED"

CXXBENCH_DEFAULT_FLAGS = "-std=c++14 -O2"

inherit cxxbench
