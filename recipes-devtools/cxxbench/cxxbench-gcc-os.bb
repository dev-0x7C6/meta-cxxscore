LICENSE = "CLOSED"

CMAKE_CXX_FLAGS_RELEASE = "-std=c++14 -Os"

inherit cxxbench
