LICENSE = "CLOSED"

CMAKE_CXX_FLAGS_RELEASE = "-std=c++14 -O1"

inherit cxxbench
